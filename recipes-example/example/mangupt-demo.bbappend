SRC_URI += "file://0001_Add_print.patch \
            file://0002_Add_print_2.patch \
           "